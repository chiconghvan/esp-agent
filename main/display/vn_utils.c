/**
 * ===========================================================================
 * @file vn_utils.c
 * @brief Chuyển đổi chuỗi UTF-8 tiếng Việt thành ASCII không dấu
 *
 * Bảng mapping bao phủ tất cả nguyên âm tiếng Việt có dấu (hoa + thường)
 * và chữ Đ/đ. Ký tự không nhận diện được sẽ bị bỏ qua.
 * ===========================================================================
 */

#include "vn_utils.h"
#include <string.h>
#include <stdbool.h>
#include <stdint.h>

/* Bảng mapping 2-byte UTF-8 → ASCII */
typedef struct { uint8_t b1; uint8_t b2; char ascii; } vn_map2_t;

/* Bảng mapping 3-byte UTF-8 → ASCII */
typedef struct { uint8_t b1; uint8_t b2; uint8_t b3; char ascii; } vn_map3_t;

/* 2-byte sequences (0xC3 xx, 0xC4 xx, 0xC6 xx) */
static const vn_map2_t map2[] = {
    /* à á â ã */
    {0xC3, 0xA0, 'a'}, {0xC3, 0xA1, 'a'}, {0xC3, 0xA2, 'a'}, {0xC3, 0xA3, 'a'},
    /* À Á Â Ã */
    {0xC3, 0x80, 'A'}, {0xC3, 0x81, 'A'}, {0xC3, 0x82, 'A'}, {0xC3, 0x83, 'A'},
    /* è é ê */
    {0xC3, 0xA8, 'e'}, {0xC3, 0xA9, 'e'}, {0xC3, 0xAA, 'e'},
    /* È É Ê */
    {0xC3, 0x88, 'E'}, {0xC3, 0x89, 'E'}, {0xC3, 0x8A, 'E'},
    /* ì í */
    {0xC3, 0xAC, 'i'}, {0xC3, 0xAD, 'i'},
    /* Ì Í */
    {0xC3, 0x8C, 'I'}, {0xC3, 0x8D, 'I'},
    /* ò ó ô õ */
    {0xC3, 0xB2, 'o'}, {0xC3, 0xB3, 'o'}, {0xC3, 0xB4, 'o'}, {0xC3, 0xB5, 'o'},
    /* Ò Ó Ô Õ */
    {0xC3, 0x92, 'O'}, {0xC3, 0x93, 'O'}, {0xC3, 0x94, 'O'}, {0xC3, 0x95, 'O'},
    /* ù ú */
    {0xC3, 0xB9, 'u'}, {0xC3, 0xBA, 'u'},
    /* Ù Ú */
    {0xC3, 0x99, 'U'}, {0xC3, 0x9A, 'U'},
    /* ý */
    {0xC3, 0xBD, 'y'},
    /* Ý */
    {0xC3, 0x9D, 'Y'},
    /* đ Đ */
    {0xC4, 0x91, 'd'}, {0xC4, 0x90, 'D'},
    /* ĩ */
    {0xC4, 0xA9, 'i'},
    /* Ĩ */
    {0xC4, 0xA8, 'I'},
    /* ũ */
    {0xC5, 0xA9, 'u'},
    /* Ũ */
    {0xC5, 0xA8, 'U'},
    /* ơ Ơ */
    {0xC6, 0xA1, 'o'}, {0xC6, 0xA0, 'O'},
    /* ư Ư */
    {0xC6, 0xB0, 'u'}, {0xC6, 0xAF, 'U'},
};
#define MAP2_COUNT (sizeof(map2) / sizeof(map2[0]))

/* 3-byte sequences (0xE1 xx xx) */
static const vn_map3_t map3[] = {
    /* ả ạ ắ ằ ẳ ẵ ặ ấ ầ ẩ ẫ ậ */
    {0xE1, 0xBA, 0xA3, 'a'}, {0xE1, 0xBA, 0xA1, 'a'},
    {0xE1, 0xBA, 0xAF, 'a'}, {0xE1, 0xBA, 0xB1, 'a'},
    {0xE1, 0xBA, 0xB3, 'a'}, {0xE1, 0xBA, 0xB5, 'a'}, {0xE1, 0xBA, 0xB7, 'a'},
    {0xE1, 0xBA, 0xA5, 'a'}, {0xE1, 0xBA, 0xA7, 'a'},
    {0xE1, 0xBA, 0xA9, 'a'}, {0xE1, 0xBA, 0xAB, 'a'}, {0xE1, 0xBA, 0xAD, 'a'},
    /* Ả Ạ Ắ Ằ Ẳ Ẵ Ặ Ấ Ầ Ẩ Ẫ Ậ */
    {0xE1, 0xBA, 0xA2, 'A'}, {0xE1, 0xBA, 0xA0, 'A'},
    {0xE1, 0xBA, 0xAE, 'A'}, {0xE1, 0xBA, 0xB0, 'A'},
    {0xE1, 0xBA, 0xB2, 'A'}, {0xE1, 0xBA, 0xB4, 'A'}, {0xE1, 0xBA, 0xB6, 'A'},
    {0xE1, 0xBA, 0xA4, 'A'}, {0xE1, 0xBA, 0xA6, 'A'},
    {0xE1, 0xBA, 0xA8, 'A'}, {0xE1, 0xBA, 0xAA, 'A'}, {0xE1, 0xBA, 0xAC, 'A'},
    /* ẻ ẽ ẹ ế ề ể ễ ệ */
    {0xE1, 0xBA, 0xBB, 'e'}, {0xE1, 0xBA, 0xBD, 'e'}, {0xE1, 0xBB, 0x87, 'e'},
    {0xE1, 0xBA, 0xBF, 'e'}, {0xE1, 0xBB, 0x81, 'e'},
    {0xE1, 0xBB, 0x83, 'e'}, {0xE1, 0xBB, 0x85, 'e'},
    {0xE1, 0xBA, 0xB9, 'e'},
    /* Ẻ Ẽ Ẹ Ế Ề Ể Ễ Ệ */
    {0xE1, 0xBA, 0xBA, 'E'}, {0xE1, 0xBA, 0xBC, 'E'}, {0xE1, 0xBB, 0x86, 'E'},
    {0xE1, 0xBA, 0xBE, 'E'}, {0xE1, 0xBB, 0x80, 'E'},
    {0xE1, 0xBB, 0x82, 'E'}, {0xE1, 0xBB, 0x84, 'E'},
    {0xE1, 0xBA, 0xB8, 'E'},
    /* ỉ ị */
    {0xE1, 0xBB, 0x89, 'i'}, {0xE1, 0xBB, 0x8B, 'i'},
    /* Ỉ Ị */
    {0xE1, 0xBB, 0x88, 'I'}, {0xE1, 0xBB, 0x8A, 'I'},
    /* ỏ ọ ố ồ ổ ỗ ộ ớ ờ ở ỡ ợ */
    {0xE1, 0xBB, 0x8F, 'o'}, {0xE1, 0xBB, 0x8D, 'o'},
    {0xE1, 0xBB, 0x91, 'o'}, {0xE1, 0xBB, 0x93, 'o'},
    {0xE1, 0xBB, 0x95, 'o'}, {0xE1, 0xBB, 0x97, 'o'}, {0xE1, 0xBB, 0x99, 'o'},
    {0xE1, 0xBB, 0x9B, 'o'}, {0xE1, 0xBB, 0x9D, 'o'},
    {0xE1, 0xBB, 0x9F, 'o'}, {0xE1, 0xBB, 0xA1, 'o'}, {0xE1, 0xBB, 0xA3, 'o'},
    /* Ỏ Ọ Ố Ồ Ổ Ỗ Ộ Ớ Ờ Ở Ỡ Ợ */
    {0xE1, 0xBB, 0x8E, 'O'}, {0xE1, 0xBB, 0x8C, 'O'},
    {0xE1, 0xBB, 0x90, 'O'}, {0xE1, 0xBB, 0x92, 'O'},
    {0xE1, 0xBB, 0x94, 'O'}, {0xE1, 0xBB, 0x96, 'O'}, {0xE1, 0xBB, 0x98, 'O'},
    {0xE1, 0xBB, 0x9A, 'O'}, {0xE1, 0xBB, 0x9C, 'O'},
    {0xE1, 0xBB, 0x9E, 'O'}, {0xE1, 0xBB, 0xA0, 'O'}, {0xE1, 0xBB, 0xA2, 'O'},
    /* ủ ụ ứ ừ ử ữ ự */
    {0xE1, 0xBB, 0xA7, 'u'}, {0xE1, 0xBB, 0xA5, 'u'},
    {0xE1, 0xBB, 0xA9, 'u'}, {0xE1, 0xBB, 0xAB, 'u'},
    {0xE1, 0xBB, 0xAD, 'u'}, {0xE1, 0xBB, 0xAF, 'u'}, {0xE1, 0xBB, 0xB1, 'u'},
    /* Ủ Ụ Ứ Ừ Ử Ữ Ự */
    {0xE1, 0xBB, 0xA6, 'U'}, {0xE1, 0xBB, 0xA4, 'U'},
    {0xE1, 0xBB, 0xA8, 'U'}, {0xE1, 0xBB, 0xAA, 'U'},
    {0xE1, 0xBB, 0xAC, 'U'}, {0xE1, 0xBB, 0xAE, 'U'}, {0xE1, 0xBB, 0xB0, 'U'},
    /* ỳ ỷ ỹ ỵ */
    {0xE1, 0xBB, 0xB3, 'y'}, {0xE1, 0xBB, 0xB7, 'y'},
    {0xE1, 0xBB, 0xB9, 'y'}, {0xE1, 0xBB, 0xB5, 'y'},
    /* Ỳ Ỷ Ỹ Ỵ */
    {0xE1, 0xBB, 0xB2, 'Y'}, {0xE1, 0xBB, 0xB6, 'Y'},
    {0xE1, 0xBB, 0xB8, 'Y'}, {0xE1, 0xBB, 0xB4, 'Y'},
};
#define MAP3_COUNT (sizeof(map3) / sizeof(map3[0]))

void vn_strip_diacritics(char *dst, const char *src, size_t dst_size)
{
    if (dst == NULL || src == NULL || dst_size == 0) return;

    const uint8_t *s = (const uint8_t *)src;
    size_t d = 0;

    while (*s && d < dst_size - 1) {
        /* ASCII thuần (1 byte) */
        if (*s < 0x80) {
            dst[d++] = (char)*s;
            s++;
            continue;
        }

        /* 3-byte UTF-8? (0xE1 xx xx) */
        if (s[0] == 0xE1 && s[1] && s[2]) {
            bool found = false;
            for (size_t i = 0; i < MAP3_COUNT; i++) {
                if (s[0] == map3[i].b1 && s[1] == map3[i].b2 && s[2] == map3[i].b3) {
                    dst[d++] = map3[i].ascii;
                    s += 3;
                    found = true;
                    break;
                }
            }
            if (found) continue;
            /* Unknown 3-byte: skip */
            s += 3;
            continue;
        }

        /* 2-byte UTF-8? (0xC0..0xDF xx) */
        if (*s >= 0xC0 && *s <= 0xDF && s[1]) {
            bool found = false;
            for (size_t i = 0; i < MAP2_COUNT; i++) {
                if (s[0] == map2[i].b1 && s[1] == map2[i].b2) {
                    dst[d++] = map2[i].ascii;
                    s += 2;
                    found = true;
                    break;
                }
            }
            if (found) continue;
            /* Unknown 2-byte: skip */
            s += 2;
            continue;
        }

        /* 4-byte UTF-8 (emoji etc): skip */
        if (*s >= 0xF0 && *s <= 0xF7) {
            s += 4;
            continue;
        }

        /* Fallback: skip byte */
        s++;
    }

    dst[d] = '\0';
}
